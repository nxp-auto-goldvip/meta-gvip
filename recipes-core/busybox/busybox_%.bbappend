FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://goldvip.cfg"
