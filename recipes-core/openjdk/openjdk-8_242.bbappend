# set ARCHFLAGS needed by adlc.make used by openjdk
EXTRA_OEMAKE += "ARCHFLAG='${TARGET_CXXFLAGS}'"
