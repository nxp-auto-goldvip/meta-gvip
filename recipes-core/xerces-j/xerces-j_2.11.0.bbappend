SRC_URI:remove += "http://archive.apache.org/dist/xerces/j/Xerces-J-src.${PV}.tar.gz"

SRC_URI:append += "http://archive.apache.org/dist/xerces/j/source/Xerces-J-src.${PV}.tar.gz"
