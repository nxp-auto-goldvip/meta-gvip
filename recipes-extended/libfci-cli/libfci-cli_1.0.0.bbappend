
RDEPENDS_${PN}_remove = "pfe"
RDEPENDS_${PN}-dbg_remove = "pfe"

