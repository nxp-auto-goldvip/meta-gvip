# Copyright 2024 NXP

require nxp-wlan-sdk-s32.inc

COMPATIBLE_MACHINE = "s32g"
