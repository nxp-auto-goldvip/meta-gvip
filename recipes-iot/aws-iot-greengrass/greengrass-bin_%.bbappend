FILES:${PN} += "\
    /usr \
    "